v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} 90 -160 0 0 {name=p4 lab=enable

}
C {ipin.sym} 90 -130 0 0 {name=p1 lab=vpos


}
C {ipin.sym} 90 -100 0 0 {name=p2 lab=vneg



}
C {iopin.sym} 70 -70 0 0 {name=p3 lab=vdd



}
C {iopin.sym} 70 -40 0 0 {name=p5 lab=vss




}
C {ipin.sym} 90 -190 0 0 {name=p6 lab=compensation_enable


}
C {opin.sym} 220 -220 0 0 {name=p7 lab=out_stage1
spice_ignore=short}
C {opin.sym} 220 -190 0 0 {name=p8 lab=out_stage2}
C {ipin.sym} 90 -220 0 0 {name=p9 lab=ibias


}
