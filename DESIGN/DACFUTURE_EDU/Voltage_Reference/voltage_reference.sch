v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} 0 -50 0 0 {name=p1 lab=enable_ota_current}
C {ipin.sym} 0 -20 0 0 {name=p3 lab=enable_osc_current
}
C {iopin.sym} 0 -90 0 0 {name=p2 lab=vdd}
C {iopin.sym} 0 -110 0 0 {name=p4 lab=vss}
C {opin.sym} 0 20 0 0 {name=p5 lab=iout_cap
}
C {opin.sym} 0 80 0 0 {name=p6 lab=iout_ota
}
C {opin.sym} 0 110 0 0 {name=p7 lab=vref
}
C {opin.sym} 0 50 0 0 {name=p8 lab=iout_res
}
