v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} 50 -220 0 0 {name=p1 lab=M0
}
C {ipin.sym} 50 -190 0 0 {name=p2 lab=M1}
C {iopin.sym} 30 -280 0 0 {name=p3 lab=vdd}
C {iopin.sym} 30 -250 0 0 {name=p4 lab=vss}
C {opin.sym} 50 -150 0 0 {name=p5 lab=enable_ota}
C {opin.sym} 50 -120 0 0 {name=p7 lab=comp_en
}
C {opin.sym} 50 -90 0 0 {name=p8 lab=enable_osc
}
C {opin.sym} 50 -60 0 0 {name=p6 lab=enable_dac
}
C {opin.sym} 50 -30 0 0 {name=p9 lab=enable_vco
}
